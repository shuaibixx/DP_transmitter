# Keil uVision project N32G031_DP_transmitter.uvprojx, settings and files
target N32G031_DP_transmitter (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32G031K8 Nationstech
  pack: Nationstech.N32G031_DFP.1.0.6
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: N32G031_DP_transmitter +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G031, USE_STDPERIPH_DRIVER, SYSCLK_FREQ=8000000, SYSCLK_SRC=SYSCLK_USE_HSI
  c include: .\Drivers\n32g031_std_periph_driver\inc;.\Drivers\CMSIS\core;.\Drivers\CMSIS\device;.\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group STARTUP
    ./Drivers/CMSIS/device/startup/: startup_n32g031.s
  group CMSIS
    ./Drivers/CMSIS/device/: system_n32g031.c
  group FWLB
    ./Drivers/n32g031_std_periph_driver/src/: misc.c n32g031_rcc.c n32g031_gpio.c n32g031_tim.c n32g031_usart.c
  group USER
    ./User/Src/: main.c n32g031_it.c delay.c soft_i2c.c hbp5023.c oled.c gp315.c usart.c
